# Keil uVision project placavaca.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: placavaca
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
    ./inc/: DS18B20_API.c GPIOAPI.c GPS_API.c TIMERAPI.c USART_API.c WATCHDOG_API.c DS18B20_API.h GPIOAPI.h GPS_API.h TIMERAPI.h USART_API.h WATCHDOG_API.h SLEEP_API.c SLEEP_API.h
software components: CMSIS:CORE 3.40.0, Device:Startup 2.1.0
