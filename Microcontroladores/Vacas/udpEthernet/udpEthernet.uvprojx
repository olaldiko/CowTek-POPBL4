# Keil uVision project udpEthernet.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: udpEthernet
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c ethernetApi.c
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, CMSIS Driver:Ethernet MAC 2.01, CMSIS Driver:Ethernet PHY:DP83848C 6.00, CMSIS Driver:Ethernet PHY:LAN8720 6.00, CMSIS Driver:Ethernet PHY:ST802RT1 6.00, CMSIS Driver:Ethernet:KSZ8851SNL 6.01, CMSIS Driver:SPI 2.01, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:ETH 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:SPI 1.1.0, Device:STM32Cube HAL:USART 1.1.0, Device:Startup 2.1.0
