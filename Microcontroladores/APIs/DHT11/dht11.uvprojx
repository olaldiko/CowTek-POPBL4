# Keil uVision project dht11.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dht11
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\Nueva carpeta\Includes
  asm include: ..\..\Nueva carpeta\Includes
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: dht11.c GPIOAPI.c TIMERAPI.c main.c
software components: CMSIS:CORE 3.40.0, Device:Startup 2.1.0
